Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Dining table D150 - v4.ifc
Time: 2023-11-10T15:10:46
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (5)
Name
 | ddd_2 - ObjectType: SketchupGroup
 | ddd_3 - ObjectType: SketchupGroup
 | ddd_1 - ObjectType: SketchupGroup
 | ddd_0 - ObjectType: SketchupGroup
 | ddd_4 - ObjectType: SketchupGroup
